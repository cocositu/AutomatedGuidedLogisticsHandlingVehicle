# Keil uVision project STM32F407ZGT6std.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F103ZGT6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_LOOPUNROLL,ARM_MATH_CM4,STM32F4xx
  c include: .\usr;.\core;.\lib\inc;.\CMSIS\DSP\Include;.\CMSIS\FreeRTOS\include;.\CMSIS\FreeRTOS\portable\RVDS\ARM_CM4F;.\hw;.\hw\LCD;.\sys;.\hw\Servo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group usr
    ./usr/: main.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h config.h
    ./CMSIS/FreeRTOS/include/: FreeRTOSConfig.h
  group core
    ./core/: core_cm4.h startup_stm32f40_41xxx.s
  group lib
    ./lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS/DSP
    ./CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ./CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ./CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ./CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ./CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ./CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ./CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ./CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ./CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ./CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
  group FreeRTOS_CODE
    ./CMSIS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./CMSIS/FreeRTOS/portable/MemMang/: heap_4.c
    ./CMSIS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group hw
    ./hw/: led.c led.h comm_uart.c comm_uart.h hwt101.c hwt101.h KinematicModel.c KinematicModel.h motor_driver.c motor_driver.h pid.c pid.h QRcode.c QRcode.h bottom_task.c bottom_task.h CarTaskConfig.c CarTaskConfig.h manipulator.c manipulator.h openmv.c openmv.h top_task.c top_task.h
  group lcd
    ./hw/LCD/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h
  group sys
    ./sys/: sys.c sys.h
  group servo
    ./hw/Servo/: LobotServoController.c LobotServoController.h
